# IAR project Project_ns.ewp, settings and files
configuration NUCLEO-WBA52CG_TFM_Appli_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA52CG ST STM32WBA52CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_ASSERT; USE_FULL_LL_DRIVER; PHY_2_10_a; PHY_40nm_2_30_a_A1; NVM_ADAPT; MBEDTLS_NO_PLATFORM_ENTROPY; MBEDTLS_CONFIG_FILE=<crypto_config.h>; BLE; STM32WBA52xx; USE_HAL_DRIVER; BL2; TFM_PSA_API; PS_ENCRYPTION; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_PLATFORM; TFM_PARTITION_INITIAL_ATTESTATION; TFM_LVL=2; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; DOMAIN_NS=1; TZ_PRIMASK_BRIDGE_ENABLE; BASIC_FEATURES=1; USE_PSA_ENCRYPTION
  ICCARM.CCIncludePath2: $FIRMWARE_BASE_DIR$\..\Drivers\CMSIS\Include; $FIRMWARE_BASE_DIR$\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; $FIRMWARE_BASE_DIR$\..\Drivers\STM32WBAxx_HAL_Driver\Inc; $FIRMWARE_BASE_DIR$\..\Drivers\BSP\STM32WBAxx_Nucleo; $FIRMWARE_BASE_DIR$\..\Drivers\BSP\Components\Common; ..\..\..\Linker; ..\..\Secure_nsclib; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\interface\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\include\mbedtls; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\interface\include\log; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\inc; ..\Secure\g\interface\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\platform\ext\cmsis; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\test\framework; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\test\suites\crypto; ..\..\NonSecure\Core\Inc; ..\..\NonSecure\System\Interfaces; ..\..\NonSecure\System\Modules; ..\..\NonSecure\System\Modules\baes; ..\..\NonSecure\System\Modules\MemoryManager; ..\..\NonSecure\System\Modules\Nvm; ..\..\NonSecure\System\Modules\Flash; ..\..\NonSecure\System\Config; ..\..\NonSecure\System\Config\Flash; ..\..\NonSecure\STM32_WPAN\App; ..\..\NonSecure\STM32_WPAN\Target; ..\..\NonSecure\System\Modules\RTDebug; ..\..\NonSecure\System\Config\Debug_GPIO; ..\..\NonSecure\System\Config\LowPower; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc\phy; $FIRMWARE_BASE_DIR$\Utilities\trace\adv_trace; $FIRMWARE_BASE_DIR$\Drivers\STM32WBAxx_HAL_Driver\Inc; $FIRMWARE_BASE_DIR$\Drivers\STM32WBAxx_HAL_Driver\Inc\Legacy; $FIRMWARE_BASE_DIR$\Utilities\misc; $FIRMWARE_BASE_DIR$\Utilities\sequencer; $FIRMWARE_BASE_DIR$\Utilities\tim_serv; $FIRMWARE_BASE_DIR$\Utilities\lpm\tiny_lpm; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\config\ble_basic; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\ble\svc\Src; $FIRMWARE_BASE_DIR$\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc\phy\_40nm_reg_files; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\link_layer\ll_sys\inc; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\ble; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\ble\stack\include; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\ble\stack\include\auto; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\ble\svc\Inc; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\ble\system\Inc; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\include\mbedtls; $FIRMWARE_BASE_DIR$\Drivers\CMSIS\Include; $FIRMWARE_BASE_DIR$\Drivers\BSP\STM32WBAxx_Nucleo; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\3rdparty\everest\include\everest; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\3rdparty\everest\include\everest\kremlin; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\3rdparty\everest\include\everest\kremlin\internal; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\3rdparty\everest\include\everest\vs2010; $FIRMWARE_BASE_DIR$\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc\_40nm_reg_files
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32WBA52xx" > output_prebuild.txt
  postbuild: cmd /C "cmd /C ..\postbuild.bat "$PROJ_DIR$"  "1.0.0" "nonsecure""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wba52xx_flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: ..\Secure\NUCLEO-WBA52CG_S\Exe\Project_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../NonSecure/System/Modules/: adc_ctrl.c app_sys.c ble_timer.c otp.c scm.c stm_list.c
  group Application/User/Core
    ../../NonSecure/Core/Src/: app_entry.c low_level_device.c low_level_flash.c main.c secure_data_uptade.c startup_stm32wbaxx.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c tfm_doorlock_service_api.c tfm_ns_lock.c tfm_radio_service_interface.c
  group Application/User/STM32_WPAN/App
    ../../NonSecure/STM32_WPAN/App/: app_ble.c dis.c dis_app.c dls.c dls_app.c ota.c ota_app.c
  group Application/User/STM32_WPAN/Target
    ../../NonSecure/STM32_WPAN/Target/: bleplat.c bpka.c host_stack_if.c linklayer_plat.c ll_sys_if.c power_table.c psa_plat_crypto.c
  group Application/User/System/Config/Debug_GPIO
    ../../NonSecure/System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../../NonSecure/System/Interfaces/: hw_aes.c hw_otp.c hw_pka.c hw_rng.c pka_p256.c stm32_lpm_if.c timer_if.c usart_if.c
  group Application/User/System/Modules/baes
    ../../NonSecure/System/Modules/baes/: baes_cmac.c baes_ecb.c
  group Application/User/System/Modules/Flash
    ../../NonSecure/System/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Application/User/System/Modules/MemoryManager
    ../../NonSecure/System/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Application/User/System/Modules/Nvm
    ../../NonSecure/System/Modules/Nvm/: nvm_emul.c
  group Application/User/System/Modules/RTDebug
    ../../NonSecure/System/Modules/RTDebug/: RTDebug.c
  group Application/User/System/Startup
    ../../NonSecure/System/Startup/: stm32wbaxx_ResetHandler.S
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    $FIRMWARE_BASE_DIR$/Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../../NonSecure/Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    $FIRMWARE_BASE_DIR$/Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_comp.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_irda.c stm32wbaxx_hal_iwdg.c stm32wbaxx_hal_lptim.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_smartcard.c stm32wbaxx_hal_smartcard_ex.c stm32wbaxx_hal_smbus.c stm32wbaxx_hal_smbus_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_tsc.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_usart.c stm32wbaxx_hal_usart_ex.c stm32wbaxx_hal_wwdg.c stm32wbaxx_ll_adc.c stm32wbaxx_ll_comp.c stm32wbaxx_ll_crc.c stm32wbaxx_ll_dma.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_i2c.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_lptim.c stm32wbaxx_ll_lpuart.c stm32wbaxx_ll_pka.c stm32wbaxx_ll_pwr.c stm32wbaxx_ll_rcc.c stm32wbaxx_ll_rng.c stm32wbaxx_ll_rtc.c stm32wbaxx_ll_spi.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_usart.c stm32wbaxx_ll_utils.c
  group Middlewares/STM32_WPAN
    $FIRMWARE_BASE_DIR$/Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    $FIRMWARE_BASE_DIR$/Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Middlewares/STM32_WPAN/ble_stack
    $FIRMWARE_BASE_DIR$/Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_basic.a
  group Middlewares/STM32_WPAN/linklayer
    $FIRMWARE_BASE_DIR$/Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Basic_lib.a
  group Middlewares/trustedfirmware/core
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/interface/src/: tfm_crypto_ipc_api.c tfm_firmware_update_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_platform_ipc_api.c tfm_ps_ipc_api.c tfm_psa_ns_api.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: UsefulBuf.c
  group Middlewares/trustedfirmware/test
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/test/suites/crypto/: crypto_tests_common.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/test/framework/: test_framework.c test_framework_helpers.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/log/: tfm_log_raw.c
  group Utilities
    $FIRMWARE_BASE_DIR$/Utilities/trace/adv_trace/: stm32_adv_trace.c
    $FIRMWARE_BASE_DIR$/Utilities/lpm/tiny_lpm/: stm32_lpm.c
    $FIRMWARE_BASE_DIR$/Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    $FIRMWARE_BASE_DIR$/Utilities/sequencer/: stm32_seq.c
    $FIRMWARE_BASE_DIR$/Utilities/tim_serv/: stm32_timer.c
