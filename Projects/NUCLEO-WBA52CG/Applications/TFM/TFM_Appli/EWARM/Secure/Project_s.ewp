# IAR project Project_s.ewp, settings and files
configuration NUCLEO-WBA52CG_TFM_Appli_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA52CG ST STM32WBA52CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32WBA52xx; USE_HAL_DRIVER; NDEBUG; TFM_PARTITION_LOG_LEVEL=3; TFM_SPM_LOG_LEVEL=3; __AS_BOUNDS__; BL2; UNDEF_PS_ENCRYPTION; TFM_PARTITION_PROTECTED_STORAGE; TFM_PARTITION_INTERNAL_TRUSTED_STORAGE; TFM_PARTITION_CRYPTO; TFM_PARTITION_PLATFORM; UNDEF_TFM_PARTITION_INITIAL_ATTESTATION; TFM_PSA_API=1; CONFIG_TFM_ENABLE_MEMORY_PROTECT; TFM_LVL=1; MULADDC_CANNOT_USE_R7; MBEDTLS_CONFIG_FILE=<tfm_mbedcrypto_config.h>; ITS_CREATE_FLASH_LAYOUT; PS_CREATE_FLASH_LAYOUT; TFM_CRYPTO_IOVEC_BUFFER_SIZE=5120; TFM_CRYPTO_ENGINE_BUF_SIZE=0x1800; PS_MAX_ASSET_SIZE=2048; PS_NUM_ASSETS=10; ITS_MAX_ASSET_SIZE=2048; ITS_NUM_ASSETS=20; T_COSE_COMPILE_TIME_CONFIG; T_COSE_USE_PSA_CRYPTO; T_COSE_USE_PSA_CRYPTO_FROM_TFM; T_COSE_DISABLE_CONTENT_TYPE; BOOT_DATA_AVAILABLE; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; INCLUDE_OPTIONAL_CLAIMS; UNDEF_FLOW_CONTROL; UNDEF_TFM_FIH_PROFILE_ON; UNDEF_TFM_FIH_PROFILE_LOW; TFM_DEV_MODE; ENABLE_BLE_STACK; TFM_PARTITION_RADIO_SERVICE; TFM_PARTITION_DOORLOCK_SERVICE; BOOT_MAX_ALIGN=16
  ICCARM.CCIncludePath2: $FIRMWARE_BASE_DIR$\Drivers\CMSIS\Include; $FIRMWARE_BASE_DIR$\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; $FIRMWARE_BASE_DIR$\Drivers\STM32WBAxx_HAL_Driver\Inc; $FIRMWARE_BASE_DIR$\Drivers\BSP\STM32WBAxx_Nucleo; $FIRMWARE_BASE_DIR$\Drivers\BSP\Components\Common; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\interface\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\interface\include\ext; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\interface\include\log; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\interface\include\os_wrapper; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\lib\ext\mbedcrypto\mbedcrypto_config; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\inc; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\src; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\lib\ext\qcbor\util; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\lib\ext\t_cose\inc; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\lib\ext\t_cose\src; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\lib\fih\inc; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\platform\ext\cmsis; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\platform\ext\driver; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\platform\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\include\; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\crypto; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\firmware_update; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\firmware_update\bootloader; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\initial_attestation; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\internal_trusted_storage; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\internal_trusted_storage\flash; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\internal_trusted_storage\flash_fs; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\lib\sprt; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\lib\sprt\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\platform; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\protected_storage; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\protected_storage\crypto; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\partitions\protected_storage\nv_counters; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\cmsis_psa; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\cmsis_psa\arch; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\secure_fw\spm\include\; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\platform\ext\common; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\platform\ext; g\interface\include; g\psa_manifest; g; g\secure_fw\partitions; g\secure_fw\spm\cmsis_psa; ..\..\..\Linker; ..\..\Secure\Inc; ..\..\Secure_nsclib; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\library; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\include\mbedtls; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mbed-crypto\include\psa; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mcuboot\boot\bootutil\include; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\mcuboot\boot\bootutil\src; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware\bl2\ext\mcuboot\include; ..\..\..\TFM_SBSFU_Boot\Inc; $FIRMWARE_BASE_DIR$\Middlewares\Third_Party\trustedfirmware; $FIRMWARE_BASE_DIR$\Drivers\BSP\OLED_Display\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_s.cmd "$PROJ_DIR$" "STM32WBA52xx"
  postbuild: cmd /C "cmd /C ..\postbuild.bat "$PROJ_DIR$"  "1.0.0" "secure""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: tfm_common_s.icf.i
  ILINK.IlinkExtraOptions: --semihosting; --redirect; __write=__write_buffered
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Secure/Src/: aes_alt.c app_rot_test.c attest_hal.c ccm_alt.c dummy_boot_seed.c dummy_crypto_keys.c dummy_device_id.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c gcm_alt.c low_level_com.c low_level_device.c low_level_flash.c low_level_rng.c md5_alt.c mpu_armv8m_drv.c nv_counters.c platform_sp.c rsa_alt.c sha1_alt.c sha256_alt.c spm_hal.c startup_stm32wbaxx.c target_cfg.c tfm_app_rot.c tfm_fih.c tfm_hal_isolation.c tfm_platform_system.c tick.c
  group Doc
    ../../: README.md
  group Drivers/BSP/OLED
    $FIRMWARE_BASE_DIR$/Drivers/BSP/OLED_Display/Src/: hal_lcd.c logo.c ssd1306.c ssd1306_fonts.c stm32wba52_Nucleo_OLED_BSP.c
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    $FIRMWARE_BASE_DIR$/Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_lptim.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Middlewares/mbed-crypto
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/mbed-crypto/library/: aes.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_slot_management.c psa_crypto_storage.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c threading.c timing.c version.c version_features.c xtea.c
  group Middlewares/mcuboot/core
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c
  group Middlewares/trustedfirmware/core
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/initial_attestation/: attest_asymmetric_key.c attest_core.c attest_token_encode.c tfm_attest.c tfm_attest_req_mngr.c tfm_attest_secure_api.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/lib/sprt/: crt_memcmp.c crt_memcpy.c crt_memmove.c crt_memset.c service_api.c sprt_partition_metadata_indicator.c tfm_sp_log_raw.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/crypto/: crypto_aead.c crypto_alloc.c crypto_asymmetric.c crypto_cipher.c crypto_hash.c crypto_init.c crypto_key.c crypto_key_derivation.c crypto_mac.c tfm_crypto_secure_api.c tfm_mbedcrypto_alt.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/spm/cmsis_psa/: exception_info.c main.c spm_ipc.c tfm_core_svcalls_ipc.c tfm_nspm_ipc.c tfm_pools.c tfm_psa_api_veneers.c tfm_thread.c tfm_wait.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/lib/fih/src/: fih.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/bl2/src/: flash_map.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/bl2/ext/mcuboot/: flash_map_extended.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/src/: ieee754.c qcbor_decode.c qcbor_encode.c UsefulBuf.c
    g/auto_generated/: intermedia_tfm_app_rot.c intermedia_tfm_crypto.c intermedia_tfm_firmware_update.c intermedia_tfm_initial_attestation.c intermedia_tfm_internal_trusted_storage.c intermedia_tfm_platform.c intermedia_tfm_protected_storage.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/internal_trusted_storage/flash/: its_flash.c its_flash_nand.c its_flash_nor.c its_flash_ram.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/internal_trusted_storage/flash_fs/: its_flash_fs.c its_flash_fs_dblock.c its_flash_fs_mblock.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/internal_trusted_storage/: its_utils.c tfm_internal_trusted_storage.c tfm_its_req_mngr.c tfm_its_secure_api.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/protected_storage/crypto/: ps_crypto_interface.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/protected_storage/: ps_encrypted_object.c ps_object_system.c ps_object_table.c ps_utils.c tfm_protected_storage.c tfm_ps_req_mngr.c tfm_ps_secure_api.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/protected_storage/nv_counters/: ps_nv_counters.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/interface/src/psa/: psa_client.c psa_lifecycle.c psa_service.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/spm/ffm/: psa_client_service_apis.c spm_log.c spm_psa_client_call.c tfm_boot_data.c tfm_core_utils.c utilities.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/lib/ext/qcbor/util/: qcbor_util.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/lib/ext/t_cose/src/: t_cose_parameters.c t_cose_sign1_sign.c t_cose_sign1_verify.c t_cose_util.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/lib/ext/t_cose/crypto_adapters/: t_cose_psa_crypto.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/spm/cmsis_psa/arch/: tfm_arch.c tfm_arch_v8m_main.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/firmware_update/: tfm_fwu.c tfm_fwu_req_mngr.c tfm_fwu_secure_api.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/platform/ext/common/: tfm_hal_isolation_mpu_v8m.c tfm_hal_its.c tfm_hal_ps.c tfm_hal_spm_logdev_peripheral.c tfm_platform.c uart_stdout.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/firmware_update/bootloader/mcuboot/: tfm_mcuboot_fwu.c
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/secure_fw/partitions/platform/: tfm_platform_secure_api.c
  group Middlewares/trustedfirmware/services
    g/auto_generated/: intermedia_tfm_doorlock_service.c intermedia_tfm_radio_service.c
    ../../Secure/Src/: tfm_doorlock_service.c tfm_radio_service.c
  group Middlewares/trustedfirmware/test
    $FIRMWARE_BASE_DIR$/Middlewares/Third_Party/trustedfirmware/log/: tfm_log_raw.c
